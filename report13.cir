* title : band pass filter

* netlist
R1 2 0 7
C1 1 2 1136n
R2 2 3 .007
C2 3 0 1136n
Vin 1 0 dc 0 ac 1
*Comment

.control
*Comment
ac dec 10 1 1000Meg
*Comment
set color0 = white
set color1 = black
set color2 = blue
*Comment
plot vdb(3)
.endc
